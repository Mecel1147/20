# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\HARDWARE\Servo;..\HARDWARE\iic;..\HARDWARE\oled;..\HARDWARE\MOTOR;..\HARDWARE\ATTITUDE;..\HARDWARE\function;..\HARDWARE\GRAYSCALE;..\HARDWARE\distance;..\HARDWARE\TIMER;..\HARDWARE\color
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/iic/: iic.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ATTITUDE/: attitude.c
    ../HARDWARE/function/: function.c
    ../HARDWARE/GRAYSCALE/: grayscale.c
    ../HARDWARE/distance/: distance.c
    ../HARDWARE/Servo/: servo.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/color/: color.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_adc.c
  group README
    ../: readme.txt
